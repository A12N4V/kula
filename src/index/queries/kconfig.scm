## tests/fixtures/langs/kconfig.Kconfig
```kconfig
source "drivers/Kconfig"
menu "Greeter"
config GREETER
	bool "Enable greeter"
	depends on HELPER
config HELPER
	bool "Helper"
endmenu
```
